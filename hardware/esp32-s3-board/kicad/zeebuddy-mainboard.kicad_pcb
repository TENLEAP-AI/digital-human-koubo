# Repository TENLEAP-AI/digital-human-koubo

## KiCad design hardware/esp32-s3-board/kicad/zeebuddy-mainboard.kicad_pcb

File hardware/esp32-s3-board/kicad/README.md (part):

# Zeebuddy 主板 V2（ESP32-S31，KiCad 10）

> **本分支 `claude/board-s31`（2026-11-14）**：原理图已按 ESP32-S31 改好，**用 KiCad 10 打开**。
> - 主控 ESP32-S31-WROOM-1U-N16R16V，符号和封装用乐鑫官方 KiCad 库（[`lib/espressif`](lib/espressif)）。
> - 引脚按 [`../docs/esp32-s31-pinmap.md`](../docs/esp32-s31-pinmap.md)；屏和触摸用 40 脚亚奇板对板母座 OK-128GF040/2-35（封装按亚奇推荐焊盘画在 `zeebuddy.pretty` 里，脚号顺序画板前要和亚奇图纸核对）。
> - 214 个元件、180 个网络；网表核对 0 错误；ERC 只剩 1 条警告（充电芯片底部散热焊盘接地，正常）。
> - **`zeebuddy-mainboard.kicad_pcb` 还是 S3 版的板子，和这份原理图对不上，不能用**，由画板工程师按新原理图重画（见 [`../docs/pcb-redesign-brief.md`](../docs/pcb-redesign-brief.md)）。
>   在本分支运行 `gen/build.sh` 只生成原理图、PDF 和封装库，不碰 PCB。
> - S3 版（V1）的原理图和布线留在分支 `claude/esp32-board-layout-2w2fx8`、`claude/backup-board-v1-routed`、`claude/board-v2-gen7-round`，下面是 V1 的说明，留作记录。

# Zeebuddy 主板 V1（KiCad 9）

ESP32-S3-WROOM-1U-N16R8 + Air780E 的主板，第一版，**草稿**：原理图已画完，PCB 已布通，
**还有几条规范没满足（见下），还不能投板。**引脚分配按 `../docs/requirements.md` 的方案三，
两颗扩展芯片的引脚按板上位置重新分过（见"还没定的"一节的表）。

> **下一轮布线进行中**（2026-11-12）：板子文件仍是全部连通的 731b83a 走线；脚本已改成按 GEN-7、VIP-1、USB-3 出底子，
> 新底子上自动布线还剩 13 ~ 19 处没连。做法、数字和要定的事见 [`reports/routing-closure.md`](reports/routing-closure.md) 第 10 节。
> 现在直接重跑脚本得到的是这个没做完的版本，不是仓库里的板子。
>
> **当前状态**（2026-11-11）：六层、板厚 1.6 mm，按 [`../docs/layout-spec.md`](../docs/layout-spec.md)（V0.3）在做。
> - `zeebuddy-mainboard.kicad_pcb`：`731b83a` 那一版 570 处连接全部布通。2026-11-12 按独立复查改了两处原理图
>   （Type-C 保护芯片 U1 第 5 脚接 VBUS；R44 改为默认贴），U1 第 5 脚这根线在现在的板子上被锁定的 USB 线围住，
>   **留作 1 处未连通**，和下一轮的 USB 重画一起做。KiCad 9.0.9 完整检查：未连通 1、布线违规 0、
>   原理图一致性（含字段差异）0。报告在 [`reports/`](reports/)。
> - 首版配置：屏用 G3 ~ G7 五根数据线（G0 ~ G2 接地），保留 TF 卡，R58 ~ R60 已删除。
> - **屏的接口没有定，定之前不要投板。**屏厂给的型号（华迪创显 HD28142C22）是 MIPI 接口，这块主板是按 8 位串行 RGB 设计的，
>   驱动不了；要屏厂答复能不能做 RGB 接口的版本。见 [`../docs/display-interface-for-vendor.md`](../docs/display-interface-for-vendor.md)。
> - **KiCad 检查通过不等于规范全部满足。**还没满足或没检查的：USB 四段里三段的等长（USB-3）；
>   1 段 4.2 mm 的 0.11 mm 窄线（GEN-1 允许的窄线最长 3 mm）；过孔到焊盘 ≥0.15 mm（GEN-7）没有写进 KiCad 规则，
>   现在按 0.10 mm 检查；另有 3 处和规范的出入等确认（见规范的"待定问题"）。
>   逐项见 [`reports/routing-closure.md`](reports/routing-closure.md)。

## 文件

| 文件 | 内容 |
|---|---|
| `zeebuddy-mainboard.pdf` | 原理图 PDF，直接看这个 |
| `zeebuddy-mainboard.kicad_pro` / `.kicad_sch` | KiCad 工程和顶层图 |
| `power.kicad_sch` | 1 电源：Type-C、充电（SY6970）、电池、3.3 V |
| `mcu.kicad_sch` | 2 主控：ESP32-S3 模组、下载口、USB 切换 |
| `expander.kicad_sch` | 3 两颗 I²C 扩展芯片、按键 |
| `cellular.kicad_sch` | 4 4G：Air780E、SIM 卡、天线 |
| `display.kicad_sch` | 5 屏、触摸、背光 |
| `camera.kicad_sch` | 6 前后摄像头、总线切换、摄像头电源 |
| `audio_tf.kicad_sch` | 7 麦克风、功放、TF 卡 |
| `zeebuddy.kicad_sym` | 工程自带的符号（Air780E、排线座等） |
| `zeebuddy-mainboard.kicad_pcb` | PCB：六层，外形、螺丝孔、210 个封装；电源、地、天线线、USB 已布好并锁定，信号线全部布通 |
| `reports/drc-report.txt` / `.json` | KiCad 9.0.9 的完整检查报告（含原理图一致性） |
| `reports/routing-closure.md` | 布线收尾记录：每处断点怎么处理的、改了什么摆位、规范核查结果、还没满足的规范、独立复查的结论 |
| `connector-positions.png` | 所有排线座的位置、第 1 脚、排线插入方向（`gen/connectors.py` 生成），给结构和排线供应商 |
| `../docs/display-interface-for-vendor.md` | 给屏厂的排线接口定义（8 位串行 RGB，主板现在的接法）：脚位表、要屏厂确认的事项、背光和触摸 |
| `../docs/display-request-serial-rgb.md` | 给屏厂的改法说明（8 位串行 RGB，一页，不含内部分析）：要求、脚位、要对方答复的问题 |
| `../docs/display-interface-qspi-proposal.md` | 给屏厂评估的 QSPI 接口定义（提案，主板还没按它改） |
| `placement-front.png` / `placement-back.png` | 正反两面主要器件的摆放示意图 |
| `routing.png` | 当前布线的示意图 |
| `freerouting/zeebuddy-mainboard.dsn` | **第二轮**给 Freerouting 用的板子文件（底子作为障碍，只有信号线要布） |
| `freerouting/zeebuddy-mainboard.ses` | 第二轮 Freerouting 的结果（2.5.0，限时 20 分钟） |
| `freerouting/round1.ses` | 第一轮的布线结果，存档用。它对应的是旧摆放（提交 `2e952f9`），不能导入现在的板子 |
| `zeebuddy.pretty/` | 工程自带的封装（Air780E、SY6970、麦克风和几个占位封装） |
| `gen/` | 生成原理图、封装库和 PCB 的脚本，见下面"PCB 是怎么生成的" |

## 这份图是脚本生成的

原理图不是在 KiCad 里手画的，而是由 `gen/design.py` 生成。每个引脚引出一小段线，接一个网络标号，
同名的标号就是连在一起，所以图上看不到长连线。

要改电路：改 `gen/design.py`，然后运行

```bash
gen/build.sh
```

它会重新生成全部图纸，用 KiCad 导出网表并和脚本里写的连接逐脚比对，再跑 ERC、导出 PDF；
然后生成封装库和 PCB，跑 DRC 和"PCB 与原理图是否一致"的检查。
直接在 KiCad 里改图，下次生成时会被覆盖。

**PCB 目前也是脚本整板生成的**，每次运行都会重摆、重布。等布线接近完成、需要手工收尾时，就不能再整板重新生成了。

## 检查结果

- 网表比对：833 个引脚全部与脚本里写的连接一致。
- KiCad ERC：0 个错误，1 个警告（功放散热焊盘接地，符号库里这个脚的类型是"未指定"，可以忽略）。
- PCB 与原理图一致性：213 个封装、全部焊盘的网络都与原理图一致。
- KiCad DRC：元件之间没有重叠，没有超出板边；已布的线没有间距、短路、孔距、板边类的违规。
  有 1 个提示：天线座封装与库里的不一致（我把它自带的禁布区从"所有层"改成了只在背面，是有意的）。
  未连接 0 个。

这些只说明"图和脚本一致、没有悬空或短接、摆放不打架"，**不代表电路经过了实物验证**。

## PCB 是怎么生成的

| 步骤 | 脚本 | 做什么 |
|---|---|---|
| 摆放 | `gen/place.py`、`gen/board.py` | 每个元件的位置；生成摆好的板子 |
| 底子 | `gen/power.py`、`gen/route.py` | `power.py` 是手工定坐标的电源铜皮和过孔，程序逐段检查间距；`route.py` 再布天线线、USB、每个地和 3.3 V 焊盘的短线加过孔，全部锁定 |
| 交给自动布线 | `gen/freeroute.py` | 生成 `freerouting/*.dsn`；布完后用 `--ses` 导入结果 |
| 收尾 | `gen/finish.py` | 清掉悬空线头，去掉违规线段并重连，补还没连上的 |
| 检查 | `gen/check.py` | 按规范逐条量数字，出"规则 — 要求 — 实测 — 结论"表 |
| 查原因 | `gen/diagnose.py` | 布不通时查是板子装不下还是布线程序的问题 |

```bash
/usr/bin/python3.12 gen/board.py .     # 摆放
/usr/bin/python3.12 gen/route.py .     # 底子（约 2 秒）
/usr/bin/python3.12 gen/freeroute.py . # 生成 .dsn
/usr/bin/python3.12 gen/check.py .     # 检查表
```

## PCB 布线现状（六层）

六层的用法：第 1、6 层放元件、短线和电源铜皮，第 2、5 层整层地，第 3 层走信号，第 4 层铺 3.3 V。

布线分两步（规范第 2 节的顺序）：**先把底子做好并锁定，再让 Freerouting 只布信号线。**
第一轮顺序反了（先布信号，电源和地的过孔事后挤不进去），所以重做。

### 底子里有什么

| 内容 | 怎么做的 |
|---|---|
| 电池 → 充电芯片 | 背面一块 2 mm 宽的铜皮，从电池焊盘直接到充电芯片的电池脚，电池电容在路上 |
| 充电芯片 → Air780E | 充电芯片转了 90°，系统输出脚朝上，接一条 2 mm 宽的铜带沿上方直通 4G 电源开关；开关管 → 220 µF → 模组供电脚是一整块铜皮。电池焊盘到模组供电脚铜皮共约 21 mm |
| 电源汇合点（PWR-16） | 在充电芯片系统输出的电容处：4G 一路往右，另一路经 4 个过孔到正面，一条 2 mm 宽的铜带一直到功放 |
| 充电回路 | 电感紧贴开关脚（铜长 2.7 mm），自举电容压在开关节点上，系统输出电容的地焊盘正对芯片的功率地脚 |
| 3.3 V 降压（正面） | 输入电容的地从芯片肚子底下接回地脚；开关脚到电感 0.65 mm；输出经 2 个过孔进第 4 层 |
| 背光升压（正面，移到了下方） | 电感在芯片正上方，二极管和输出电容在左侧，高频回路在 2 mm 以内 |
| 5 V 输入（VBUS） | Type-C 两组供电脚各引一条 0.6 mm 的线，从保护芯片两侧绕过定位柱，到 TVS 汇成 1.0 mm，沿下边缘走，再转到背面从 SIM 卡座底下（避开卡座的触点窗）到充电芯片 |
| 天线线 | 和以前一样：0.34 mm 直线、第 5 层只在天线座焊盘下开窗。新增：线两侧各两条地线，把 1 mm 的隔离带实实在在占住 |
| USB | 四段都已布好并锁定（等长还没达标，见下） |
| 地和 3.3 V | 每个焊盘一段短线加一个过孔，共 236 个；先打电容的，再接引脚 |

### 按规范量出来的结果

`gen/check.py` 的输出（节选）：

| 规则 | 要求 | 实测 | 结论 |
|---|---|---|---|
| DRC | 间距、短路、孔距、板边等 0 条 | 0 条 | 通过 |
| 原理图一致性 | 0 处差异 | 0 处 | 通过 |
| 底子完整 | 电源、地、3.3 V、天线、USB 全部连上 | 0 处没连 | 通过 |
| PWR-1 | 电池、系统电源、4G 供电的铜皮 ≥2.0 mm；收窄处 ≥1.0 mm、长 ≤2 mm；引脚处按引脚宽 | 收窄处最窄 1.1 mm、最长 1.8 mm | 通过 |
| PWR-2 | 电池焊盘到 Air780E 供电脚：铜皮 ≤30 mm、≤15 mΩ | 约 21 mm、约 6.1 mΩ（按方块数估算，不含充电芯片和开关管） | 通过 |
| PWR-3 | 220 µF 正极到模组供电脚 ≤1.8 mm，电容在电流的路上 | 1.76 mm | 通过 |
| PWR-5 | 220 µF 地焊盘旁 ≥3 个 0.3 mm 地孔 | 3 个 | 通过 |
| PWR-8 | 换层过孔数：系统电源 ≥4，VBUS 和 3.3 V 主干 ≥2 | 4 / 2 / 2 / 2 / 2 | 通过 |
| PWR-12 | 开关节点铜长 ≤3 mm，不打过孔 | 充电 2.74 mm、3.3 V 降压 0.64 mm、背光 0.84 mm，均无过孔 | 通过 |
| PWR-14 | 散热焊盘地孔：充电芯片 ≥5，功放 ≥4 | 6 个、4 个 | 通过 |
| DEC-6 | ESP32 底部地焊盘 ≥9 个地孔 | 12 个 | 通过 |
| RF-5 | 天线线两侧地孔间距 ≤2 mm | 14 个，最大间隔 1.8 mm | 通过 |
| RF-6 | 天线线总长 ≤15 mm | 6.5 mm | 通过 |
| RF-9 | 背面其它信号离天线线 ≥1 mm | 最近 2.0 mm | 通过 |
| RF-11 | 天线座每个地焊盘旁 ≥2 个地孔 | 5 个、2 个 | 通过 |
| USB-3 | 每段两根线长度差 ≤0.5 mm | 1.8 / 0 / 3.3 / 2.6 mm | **三段不通过** |

这张表只覆盖底子负责的规则（电源、地孔、天线线、USB 长度）。信号类的规则还没有写进脚本。

### 和规范有出入的地方

这几处已经记进规范的"待定问题"，等确认：

- **USB 等长（USB-3）**：四段里三段没达标。功能上不会有问题（常见设计指南的上限约 3.8 mm），但没达到规范收紧后的 0.5 mm。
- **VBUS 线宽（PWR-9）**：Type-C 旁边有约 7 mm 是两条 0.6 mm 并联，不是一条 1.0 mm（定位柱和保护芯片之间放不下）。
- **TVS 的位置（PWR-7）**：离 Type-C 供电脚约 6 mm，规范的判据是 2 mm（那一带正面没有空位）。
- **充电输入电容的地（PWR-11）**：芯片的引脚排列不允许同一面直接连，改为经相邻地层回流，孔紧挨焊盘。

另外有两处要留意：

- 5 V 输入线有一段从 SIM 卡座底下走（背面，避开了卡座封装标出的 6 个触点窗）。卡座的实际型号定了以后要对着图纸再确认一次。
- 4G 电源开关用的是 AO3401A，数据手册给的导通电阻上限是 60 mΩ（栅压 4.5 V 时）、85 mΩ（2.5 V 时）。
  按 2 A 算会掉 0.12 V 以上，占了"跌落 ≤300 mV"预算的四成。这是原理图层面的事，这次没有动，
  打样前值得换一颗导通电阻更低的管子。

### 第三轮：布通（2026-11-11）

第二轮停在"三个信号层装不下这么多交叉"。第三轮没有加层，改的是交叉本身：

| 改了什么 | 为什么 |
|---|---|
| 前摄排线座 J11 移到上边缘右侧，紧挨总线切换芯片；按键排线座 J5 左移 10 mm | 前摄的 14 根线原来要横穿 25 mm 的 4G 模组外围 |
| 两颗扩展芯片的信号按器件在板上的位置重新分配（6 个信号换了芯片或引脚） | 左边的中断线接在右边的芯片上，右边的摄像头控制线接在中间的芯片上，各跨 30 ~ 65 mm |
| 删除 R58 ~ R60（屏低 3 位借 TF 卡线的选配） | 三条 40 mm 以上的线横穿全板，首版用不上 |
| U8 下移 0.8 mm，U7 转 180° | U8 的中断脚被两个 3.3 V 脚的连线盖死；U7 的按键脚背对着它们的上拉电阻 |
| 底子里手工加了 4 处短线（`power.py`） | TF 卡座第 4、5 脚，U8 第 18 脚，U7 的中断脚：这些脚光靠锁定的铜就被围住，自动布线解不了 |
| 测试点、时钟串联电阻、稳压芯片的输出电容等挪到它们所连的引脚旁 | 缩短支线，让出通道 |

找这类问题用的办法是在只有底子的板子上逐个引脚试"能不能出来"（出不来的就是被锁定的铜围死的），
以及对每一处没连上的连接算"最短的路要穿过哪些线、沿途有多少过孔"。

Notes on the sheet:
Zeebuddy 主板 V1 原理图（草稿）
主控 ESP32-S3-WROOM-1U-N16R8，4G 模组 Air780E（可换贴北美版 Air780EEN）。 各页之间靠同名的网络标号连接；引脚分配见 docs/requirements.md 的方案三。
画板之前还要确认的： 1. 屏 LB28BOE47：背光电压电流、VCI 电压、排线间距和上下接、8 根数据线里哪几根有效、能否只用 DE。 2. 触摸屏：芯片型号、排线脚位。 3. 前摄：型号、排线脚位、10 脚要不要供电。 4. 电池（2000 mAh，最大充电 0.5C）：电池座型号、有没有温度电阻脚。 5. 按键：排线脚位，是否包含开关机键。 6. 各连接器的具体型号（Type-C、SIM 卡座、TF 卡座、排线座、电池座、喇叭座）。 7. 220 µF 钽电容的高度是否放得进外壳。
本图由 gen/design.py 生成。改电路请改脚本后运行 gen/build.sh，不要直接在 KiCad 里改图。

Parts:
C1: 47nF; C_0402_1005Metric
C2: 1µF 25V; C_0603_1608Metric
C3: 10µF 25V; C_0805_2012Metric
C4: 4.7µF; C_0603_1608Metric
C5, C6, C7: 10µF; C_0603_1608Metric
C8: 22pF; C_0402_1005Metric
C9, C10, C11: 22µF; C_0805_2012Metric
D1: TVS 5V; D_SOD-123F
D2: 充电灯; LED_0402_1005Metric
H1: Ø1.6 螺丝孔（无铜环）; MountingHole_1.6mm_NPTH
H2, H3, H4: Ø1.6 螺丝孔; MountingHole_1.6mm_Pad
J1: Type-C 16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: 电池焊盘; BatteryPads
L1: 1µH 4A; L_Sunlord_MWSA0402S
L2: 2.2µH 2A; L_Changjiang_FNR252012S
R1, R2: 5.1k; R_0402_1005Metric
R3: 680R 1%; R_0402_1005Metric
R4, R5, R6: 10k; R_0402_1005Metric
R7: 2.2k; R_0402_1005Metric
R8: 0R (不贴); R_0402_1005Metric; not fitted
R9: 100k 1%; R_0402_1005Metric
R10: 22.1k 1%; R_0402_1005Metric
R11: 100k; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TP; TestPad_D1.0mm
U1: USBLC6-2SC6; SOT-23-6
U2: SY6970QCC; SY6970_QFN-24_4x4mm
U3: SY8089AAAC（可换 TLV62569DBV）; SOT-23-5

Connections:
+3V3: C8.1, C10.1, C11.1, L2.2, R6.1, R7.1, R9.1, TP5.1; also elsewhere on the board
BUCK_EN: R11.2, U3.1 (EN)
BUCK_FB: C8.2, R9.2, R10.1, U3.5 (FB)
BUCK_SW: L2.1, U3.3 (SW)
CHG_BTST: C1.1, U2.21 (BST)
CHG_DPDM: U2.2 (DP), U2.3 (DM)
CHG_ILIM: R3.1, U2.10 (ILIM)
CHG_INT: R6.2, U2.7 (INT); also elsewhere on the board
CHG_LED_A: D2.2 (A), R7.2
CHG_PMID: C3.1, U2.23 (PMID)
CHG_QON: R8.1, TP1.1, U2.12 (~QON)
CHG_REGN: C4.1, R4.1, U2.22 (REGN)
CHG_STAT: D2.1 (K), U2.4 (STAT)
CHG_SW: C1.2, L1.1, U2.19 (LX), U2.20 (LX)
CHG_TS: R4.2, R5.1, U2.11 (NTC)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, D1.2 (A2), H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, R1.2, R2.2, R3.2, R5.2, R10.2, TP6.1, TP7.1, U1.2 (GND), U2.8 (OTG), U2.9 (~CE), U2.17 (PGND), U2.18 (PGND), U2.25 (PGND), U3.2 (GND); also elsewhere on the board
I2C_SCL: U2.5 (SCL); also elsewhere on the board
I2C_SDA: U2.6 (SDA); also elsewhere on the board
KEY1: R8.2; also elsewhere on the board
USBC_CC1: J1.A5 (CC1), R1.1
USBC_CC2: J1.B5 (CC2), R2.1
USBC_DM: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2); also elsewhere on the board
USBC_DP: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1); also elsewhere on the board
VBAT: C7.1, J2.1, TP3.1, U2.13 (BAT), U2.14 (BAT)
VBUS: C2.1, D1.1 (A1), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP2.1, U1.5 (VBUS), U2.1 (BUS)
VSYS: C5.1, C6.1, C9.1, L1.2, R11.1, TP4.1, U2.15 (SYS), U2.16 (SYS), U3.4 (VIN); also elsewhere on the board

Notes on the sheet:
Type-C 输入
USB 数据线只去 ESD 管和 USB 切换芯片，不接充电芯片， 所以不会触发快充升压，VBUS 一直是 5 V。
充电和电源路径（SY6970，I²C 地址 0x6A）
没接电池温度电阻：NTC 脚用两颗 10k 固定在正常窗口。OTG、CE 接地：不用反向升压，充电默认打开。 电池 2000 mAh，最大充电 0.5C = 1 A。芯片上电默认的充电电流是 2.048 A，所以默认状态靠硬件压住输入功率： ILIM = 680 Ω → 输入约 0.53 A（360 / 680），5 V 下最多约 3 W，电池电流最坏约 0.94 A； DP、DM 互相短接、不接 USB 数据线 → 不会和快充适配器握手，VBUS 一直是 5 V。 固件运行时：充电电流设 960 mA，关掉 ILIM 脚的限制并把输入限流设到 1.5 ~ 2 A，定时喂 I²C 看门狗。 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
电池座和 3.3 V 降压
输出 = 0.6 V × (1 + 100k / 22.1k) = 3.31 V。电池低于 3.4 V 左右时输出会跟着往下掉，固件要提前关机。
电源标记、测试点、螺丝孔

Parts:
C12: 22µF; C_0805_2012Metric
C13, C15: 100nF; C_0402_1005Metric
C14: 1µF; C_0402_1005Metric
J3: 下载 / 调试焊盘; ProgPads_1x06
R12, R13: 10k; R_0402_1005Metric
R14, R15: 2.2k; R_0402_1005Metric
R16: 100k; R_0402_1005Metric
R17: 4.7k; R_0402_1005Metric
R18, R19: 0R; R_0402_1005Metric
SW1: 复位; SW_SPST_B3U-1000P
SW2: BOOT（GPIO0）; SW_SPST_B3U-1000P
TP8, TP9: TP; TestPad_D1.0mm
U4: ESP32-S3-WROOM-1U-N16R8; ESP32-S3-WROOM-1U
U5: 803 型 3.08V 开漏 (不贴); SOT-23; not fitted
U6: FSUSB42MUX; MSOP-10_3x3mm_P0.5mm

Connections:
+3V3: C12.1, C13.1, C15.1, J3.1, R12.1, R13.1, R14.1, R15.1, U4.2 (3V3), U5.3 (VCC), U6.1 (VCC); also elsewhere on the board
CAM_D0: U4.4 (IO4); also elsewhere on the board
CAM_D1: U4.5 (IO5); also elsewhere on the board
CAM_D2: U4.6 (IO6); also elsewhere on the board
CAM_D3: U4.7 (IO7); also elsewhere on the board
CAM_D4: U4.12 (IO8); also elsewhere on the board
CAM_D5: U4.17 (IO9); also elsewhere on the board
CAM_D6: U4.18 (IO10); also elsewhere on the board
CAM_D7: U4.19 (IO11); also elsewhere on the board
CAM_HREF: U4.22 (IO14); also elsewhere on the board
CAM_PCLK: U4.20 (IO12); also elsewhere on the board
CAM_VSYNC: U4.21 (IO13); also elsewhere on the board
ESP_DM: R19.1, U4.13 (USB_D-)
ESP_DP: R18.1, U4.14 (USB_D+)
ESP_EN: C14.1, J3.3, R12.2, SW1.1, U4.3 (EN), U5.2 (~RESET)
ESP_USB_DM: R19.2, U6.4 (D-)
ESP_USB_DP: R18.2, U6.3 (D+)
EXP_INT: U4.9 (IO16); also elsewhere on the board
GND: C12.2, C13.2, C14.2, C15.2, J3.2, R16.2, R17.2, SW1.2, SW2.2, U4.1 (GND), U4.40 (GND), U4.41 (GND), U5.1 (GND), U6.5 (GND), U6.10 (~OE); also elsewhere on the board
I2C_SCL: R15.2, TP9.1, U4.38 (IO2); also elsewhere on the board
I2C_SDA: R14.2, TP8.1, U4.39 (IO1); also elsewhere on the board
I2S_BCLK: J3.4, R13.2, SW2.1, U4.27 (IO0); also elsewhere on the board
I2S_DIN: U4.11 (IO18); also elsewhere on the board
I2S_DOUT: U4.15 (IO3); also elsewhere on the board
I2S_WS: U4.16 (IO46); also elsewhere on the board
LCD_BL_PWM: R16.1, U4.26 (IO45); also elsewhere on the board
LCD_DE: U4.25 (IO48); also elsewhere on the board
LCD_G3: U4.31 (IO38); also elsewhere on the board
LCD_G4: U4.32 (IO39); also elsewhere on the board
LCD_G5: U4.33 (IO40); also elsewhere on the board
LCD_G6: U4.34 (IO41); also elsewhere on the board
LCD_G7: U4.35 (IO42); also elsewhere on the board
LCD_PCLK: U4.24 (IO47); also elsewhere on the board
LTE_USB_DM: U6.8 (HSD2-); also elsewhere on the board
LTE_USB_DP: U6.9 (HSD2+); also elsewhere on the board
SD_CLK: U4.8 (IO15); also elsewhere on the board
SD_CMD: U4.10 (IO17); also elsewhere on the board
SD_D0: U4.23 (IO21); also elsewhere on the board
U0RXD: J3.6, U4.36 (RXD0); also elsewhere on the board
U0TXD: J3.5, U4.37 (TXD0); also elsewhere on the board
USBC_DM: U6.6 (HSD1-); also elsewhere on the board
USBC_DP: U6.7 (HSD1+); also elsewhere on the board
USB_SEL: R17.1, U6.2 (SEL); also elsewhere on the board

Notes on the sheet:
ESP32-S3-WROOM-1U-N16R8
预留的复位监控芯片：电池供电时 3.3 V 可能缓慢下降， 如果实测有上电不启动的情况就贴上。要用开漏输出的型号。
启动配置脚： GPIO0（音频 BCLK）：上拉；BOOT 键或下载焊盘拉低进下载模式。 GPIO3（功放数据）：不加上下拉。 GPIO45（背光调光）：下拉，上电背光关。 GPIO46（音频 WS）：不能接上拉。 GPIO35 ~ 37 被模组内的八线 PSRAM 占用，悬空。 GPIO43 / 44 是串口 0（下载、日志），同时经电阻去屏的 VSYNC / HSYNC。
GPIO 分配 0 音频 BCLK 1 I²C SDA 2 I²C SCL 3 功放数据 4 ~ 11 摄像头 D0 ~ D7 12 摄像头 PCLK 13 摄像头 VSYNC 14 摄像头 HREF 15 TF CLK 16 扩展芯片中断 17 TF CMD
18 麦克风数据 19 USB D− 20 USB D+ 21 TF D0 38 ~ 42 屏 G3 ~ G7 43 屏 VSYNC / 串口发 44 屏 HSYNC / 串口收 45 背光调光 46 音频 WS 47 屏 DOTCLK 48 屏 DE
USB 切换（FSUSB42）
USB_SEL = 0（默认）：ESP32-S3 的 USB 接 Type-C，插电脑可直接下载和看日志。 USB_SEL = 1：ESP32-S3 做主机，接 Air780E 的 USB。 两颗 0R 贴近模组，USB 信号有问题时可换成 22 ~ 33 Ω。

Parts:
C16, C17: 100nF; C_0402_1005Metric
J4: 按键排线 A; FPC_0.5mm_6P_Placeholder
J5: 按键排线 B; FPC_0.5mm_6P_Placeholder
R20, R21, R22, R23, R24, R25, R26, R27, R28: 10k; R_0402_1005Metric
TP10: TP; TestPad_D1.0mm
U7, U8: XL9555QF24; WQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm

Connections:
+3V3: C16.1, C17.1, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, U7.21 (VCC), U8.21 (VCC), U8.23 (A1); also elsewhere on the board
CAMF_PWDN: U7.7 (P06); also elsewhere on the board
CAMR_PWDN: U8.7 (P06); also elsewhere on the board
CAM_PWR_EN: U8.6 (P05); also elsewhere on the board
CAM_RST: U7.12; also elsewhere on the board
CAM_SEL: U7.10; also elsewhere on the board
CHG_INT: U8.10; also elsewhere on the board
EXP_INT: R28.1, U7.22 (~INT), U8.22 (~INT); also elsewhere on the board
EXP_SPARE: TP10.1, U7.13
GND: C16.2, C17.2, J4.1 (GND), J4.6 (GND), J4.MP (SHELL), J5.1 (GND), J5.6 (GND), J5.MP (SHELL), U7.9 (GND), U7.18 (A0), U7.23 (A1), U7.24 (A2), U7.25 (EPAD), U8.9 (GND), U8.18 (A0), U8.24 (A2), U8.25 (EPAD); also elsewhere on the board
I2C_SCL: U7.19 (SCL), U8.19 (SCL); also elsewhere on the board
I2C_SDA: U7.20 (SDA), U8.20 (SDA); also elsewhere on the board
KEY1: J4.2 (K1), R20.1, U7.1 (P00); also elsewhere on the board
KEY2: J4.3 (K2), R21.1, U7.2 (P01)
KEY3: J4.4 (K3), R22.1, U7.3 (P02)
KEY4: J5.2 (K1), R23.1, U7.4 (P03)
KEY5: J5.3 (K2), R24.1, U7.5 (P04)
KEY6: J5.4 (K3), R25.1, U7.6 (P05)
LCD_CS: U8.2 (P01); also elsewhere on the board
LCD_RST: U8.1 (P00); also elsewhere on the board
LCD_SCL: U8.3 (P02); also elsewhere on the board
LCD_SDA: U8.4 (P03); also elsewhere on the board
LTE_PWRKEY_EN: U8.14; also elsewhere on the board
LTE_PWR_EN: U8.13; also elsewhere on the board
LTE_RESET_EN: U8.15; also elsewhere on the board
LTE_STATUS_N: U7.11; also elsewhere on the board
PA_EN: U8.12; also elsewhere on the board
SD_DET: R27.1, U7.8 (P07); also elsewhere on the board
TP_INT: R26.1, U8.17; also elsewhere on the board
TP_RST: U8.5 (P04); also elsewhere on the board
USB_SEL: U8.16; also elsewhere on the board

Notes on the sheet:
两颗 16 位 I²C 扩展芯片
上：地址 0x20，在板子右侧。按键、TF 卡检测、4G 状态是输入；前摄 PWDN、摄像头切换、摄像头复位、备用脚是输出。 没用到的 P14 ~ P17 固件里设成输出，避免悬空的输入脚乱触发中断。 下：地址 0x22，在板子中间偏左。触摸中断、充电中断是输入，其余是输出。P07、P11 不用（被天线线的地孔围住， 线出不来），固件里设成输出。不用 0x21，前摄常见型号占这个地址。 两颗的 INT 并在一起：任何一个输入脚变化都会把 INT 拉低。信号按器件在板上的位置分配，不按输入输出分。
XL9555 上电后所有脚是输入，芯片内部每个脚有 100 kΩ 上拉。可换脚位相同的 TCA9555RTWR（没有内部上拉）。 需要默认为低的输出都在各自的页上加了能压过它的下拉（2.2k ~ 10k）。
上拉、去耦
按键排线座（脚位待定）
参考主板有两个 6 脚按键排线座， 这里先按每个座 3 个键 + 地来画。 按键按下接地。

Parts:
C18: 22nF; C_0402_1005Metric
C19: 220µF 钽; CP_EIA-3528-21_Kemet-B
C20, C24: 100nF; C_0402_1005Metric
C21, C25, C26, C27, C28: 33pF; C_0402_1005Metric
C22: 10pF; C_0402_1005Metric
C23: 10nF; C_0402_1005Metric
C29, C30: 待调 (不贴); C_0402_1005Metric; not fitted
D3: TVS 5V; D_SOD-323
D4: 网络灯; LED_0402_1005Metric
J6: Nano SIM 卡座; nanoSIM_GCT_SIM8060-6-1-14-00
J7: IPEX 座; U.FL_Hirose_U.FL-R-SMT-1_Vertical
Q1: AO3401A; SOT-23
Q2, Q3, Q4, Q5, Q6: MMBT3904; SOT-23
R29: 470k; R_0402_1005Metric
R30, R48: 100k; R_0402_1005Metric
R31, R32, R33, R34, R35, R36, R39, R44: 10k; R_0402_1005Metric
R37, R40: 4.7k; R_0402_1005Metric
R38, R41: 47k; R_0402_1005Metric
R42: 2.2k; R_0402_1005Metric
R43: 0R (不贴); R_0402_1005Metric; not fitted
R45, R46, R47: 22R; R_0402_1005Metric
R49: 0R; R_0402_1005Metric
TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20: TP; TestPad_D1.0mm
U9: Air780E（北美版换贴 Air780EEN）; Air780E
U10: SRV05-4; SOT-23-6

Connections:
+3V3: R39.1; also elsewhere on the board
GND: C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, D3.2 (A2), J6.5 (GND), J6.SH (SHELL), J7.2 (Ext), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), R32.2, R34.2, R36.2, R38.2, R41.2, R43.2, U9.1 (GND), U9.10 (GND), U9.27 (GND), U9.34 (GND), U9.36 (GND), U9.37 (GND), U9.40 (GND), U9.41 (GND), U9.45 (GND), U9.46 (GND), U9.47 (GND), U9.48 (GND), U9.70 (GND), U9.71 (GND), U9.72 (GND), U9.73 (GND), U9.88 (GND), U9.89 (GND), U9.90 (GND), U9.91 (GND), U9.92 (GND), U9.93 (GND), U9.94 (GND), U9.95 (GND), U10.2 (VN); also elsewhere on the board
LTE_ANT: C29.1, R49.1, U9.35 (LTE_ANT)
LTE_ANT_C: C30.1, J7.1 (In), R49.2
LTE_DBG_RX: TP19.1, U9.38 (DBG_RXD)
LTE_DBG_TX: TP20.1, U9.39 (DBG_TXD)
LTE_IOSEL: R43.1, U9.100 (IO_Volt_Set)
LTE_NETLED_A: D4.2 (A), R42.2
LTE_NETLED_K: D4.1 (K), Q6.3 (C)
LTE_NET_B: Q6.1 (B), R40.2, R41.1
LTE_NET_STATUS: R40.1, U9.16 (NET_STATUS)
LTE_PWRKEY: Q3.3 (C), TP11.1, U9.7 (PWRKEY)
LTE_PWRKEY_B: Q3.1 (B), R33.2, R34.1
LTE_PWRKEY_EN: R33.1; also elsewhere on the board
LTE_PWR_B: Q2.1 (B), R31.2, R32.1
LTE_PWR_C: Q2.3 (C), R30.2
LTE_PWR_EN: R31.1; also elsewhere on the board
LTE_PWR_G: C18.1, Q1.1 (G), R29.2, R30.1
LTE_RESET_B: Q4.1 (B), R35.2, R36.1
LTE_RESET_EN: R35.1; also elsewhere on the board
LTE_RESET_N: C23.1, Q4.3 (C), U9.15 (RESET_N)
LTE_RXD: TP17.1, U9.17 (MAIN_RXD)
LTE_STATUS: R37.1, U9.25 (STATUS)
LTE_STATUS_B: Q5.1 (B), R37.2, R38.1
LTE_STATUS_N: Q5.3 (C), R39.2; also elsewhere on the board
LTE_TXD: TP18.1, U9.18 (MAIN_TXD)
LTE_USB_BOOT: TP13.1, U9.82 (USB_BOOT)
LTE_USB_DM: TP15.1, U9.60 (USB_DM); also elsewhere on the board
LTE_USB_DP: TP14.1, U9.59 (USB_DP); also elsewhere on the board
LTE_VBUS: R44.2, TP16.1, U9.61 (VBUS)
LTE_VDD_EXT: TP12.1, U9.24 (VDD_EXT)
LTE_VREF: R48.1, U9.99 (RefVolt)
SIM_CLK: R46.1, U9.13 (USIM_CLK)
SIM_CLK_C: C27.1, J6.3 (CLK), R46.2, U10.3 (IO2)
SIM_DAT: R47.1, U9.11 (USIM_DAT)
SIM_DAT_C: C28.1, J6.7 (IO), R47.2, U10.4 (IO3)
SIM_DET: J6.SW (DET), R48.2, U9.79 (USIM_DET), U10.6 (IO4)
SIM_RST: R45.1, U9.12 (USIM_RST)
SIM_RST_C: C26.1, J6.2 (RST), R45.2, U10.1 (IO1)
SIM_VDD: C24.1, C25.1, J6.1 (VCC), U9.14 (USIM_VDD), U10.5 (VP)
VDD_4G: C18.2, C19.1, C20.1, C21.1, C22.1, D3.1 (A1), Q1.3 (D), R42.1, R44.1, U9.42 (VBAT), U9.43 (VBAT)
VSYS: Q1.2 (S), R29.1; also elsewhere on the board

Notes on the sheet:
模组电源开关（可彻底断电）
栅极到漏极的 22nF 让输出慢慢升起来， 给 220µF 充电时不会把 VSYS 拉垮。
开机、关机、状态（全部经三极管，与模组 IO 电平无关）
PWRKEY、RESET_N 模组内部已有上拉，外面不能再加上拉。 PWRKEY 拉低 1.5 s 开机；RESET_N 拉低是硬关机，不是重启。 STATUS 经三极管反相：模组开机后 LTE_STATUS_N 为低。
Air780E
61 脚（VBUS，USB 插入检测）经 10k 接模组自己的供电：板上 4G 的数据只走 USB， 电池供电时没有外部 5 V，这个脚不拉高模组可能不枚举。接法和阻值待合宙确认。
100 脚不接（Air780EEN 只有 1.8 V 电平）。主串口、调试串口、USB、 USB_BOOT 只引到测试点，用于升级模组固件和抓日志。 53 个悬空焊盘（AT 方式下不接）在符号里是隐藏脚，不能接地。
SIM 卡（Nano SIM 自弹卡座）
4G 天线（50 Ω，π 型匹配）
两颗对地电容先不贴，天线调试后定值。Wi-Fi 天线座在 ESP32 模组上。
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