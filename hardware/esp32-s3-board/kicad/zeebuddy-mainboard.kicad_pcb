# Repository TENLEAP-AI/digital-human-koubo (continued)

## KiCad design hardware/esp32-s3-board/kicad/zeebuddy-mainboard.kicad_pcb (continued)

Parts:
C31: 1µF; C_0402_1005Metric
C32, C33: 100nF; C_0402_1005Metric
C34: 4.7µF; C_0603_1608Metric
C35: 2.2µF 50V; C_0805_2012Metric
D5: 肖特基 40V; D_SOD-323
J8: 屏排线座 22P 0.5mm; FPC_0.5mm_22P_Placeholder
J9: 触摸排线座 6P（脚位待定）; FPC_0.5mm_6P_Placeholder
L3: 22µH; L_Changjiang_FNR252012S
R50: 33R; R_0402_1005Metric
R51: 470R; R_0402_1005Metric
R52: 100R; R_0402_1005Metric
R53: 4.7k; R_0402_1005Metric
R54, R55, R56, R57: 0R; R_0402_1005Metric
R61: 10k; R_0402_1005Metric
R62: 10R 1%; R_0402_1005Metric
U11: SY7200AABC; SOT-23-6

Connections:
+3V3: C33.1, J9.1 (VDD), R54.1, R61.1; also elsewhere on the board
BL_SW: D5.2 (A), L3.2, U11.1 (LX)
GND: C31.2, C32.2, C33.2, C34.2, C35.2, J8.21 (GND), J8.22 (GND), J8.MP (SHELL), J9.2 (GND), J9.MP (SHELL), R53.2, R55.2, R56.2, R57.2, R62.2, U11.2 (GND); also elsewhere on the board
I2C_SCL: J9.3 (SCL); also elsewhere on the board
I2C_SDA: J9.4 (SDA); also elsewhere on the board
LCD_BL_PWM: U11.4 (EN/PWM); also elsewhere on the board
LCD_CS: J8.15 (CS); also elsewhere on the board
LCD_DE: J8.18 (DE); also elsewhere on the board
LCD_G0: J8.14 (G0), R55.1
LCD_G1: J8.13 (G1), R56.1
LCD_G2: J8.12 (G2), R57.1
LCD_G3: J8.11 (G3); also elsewhere on the board
LCD_G4: J8.10 (G4); also elsewhere on the board
LCD_G5: J8.9 (G5); also elsewhere on the board
LCD_G6: J8.8 (G6); also elsewhere on the board
LCD_G7: J8.7 (G7); also elsewhere on the board
LCD_HSYNC: J8.17 (HSYNC), R52.2
LCD_LEDA: C35.1, D5.1 (K), J8.1 (LEDA), U11.5 (OVP)
LCD_LEDK: J8.2 (LEDK), R62.1, U11.3 (FB)
LCD_PCLK: R50.1; also elsewhere on the board
LCD_PCLK_R: J8.16 (DOTCLK), R50.2
LCD_RST: J8.20 (RST), R53.1; also elsewhere on the board
LCD_SCL: J8.4 (SCL); also elsewhere on the board
LCD_SDA: J8.3 (SDA); also elsewhere on the board
LCD_VCI: C31.1, C32.1, J8.6 (VCI), R54.2
LCD_VSYNC: J8.19 (VSYNC), R51.2
TP_INT: J9.5 (INT); also elsewhere on the board
TP_RST: J9.6 (RST), R61.2; also elsewhere on the board
U0RXD: R52.1; also elsewhere on the board
U0TXD: R51.1; also elsewhere on the board
VSYS: C34.1, L3.1, U11.6 (IN); also elsewhere on the board

Notes on the sheet:
屏 LB28BOE47（480 × 640，NV3049F）和触摸
数据线只接高 5 位（G3 ~ G7），低 3 位经 0R 接地。 首版不做 8 位全接：那要借 TF 卡的 3 根线，两者不能同时用。 要 8 位全接又保留 TF 卡，需要重新分配 ESP32 的引脚。 屏的复位有下拉：扩展芯片初始化之前屏保持复位， 上电时串口 0 打印的启动信息不会被屏当成同步信号。 屏的三线 SPI（CS、SCL、SDA）和复位在扩展芯片上。
触摸芯片型号和排线脚位还没拿到，这里按常见的 6 脚定义占位。
背光升压恒流（SY7200A）
LED 电流 = 0.2 V / 10 Ω = 20 mA。 按华迪创显 HD28142C22 的规格书：6 颗灯串联，18 V、20 mA， 电流的绝对上限也是 20 mA，不能再调高。 GPIO45 输出 PWM 调光（20 kHz ~ 1 MHz），上电默认低 = 背光关。 屏没插时输出会升到过压保护点（约 30 V），输出电容选 50 V。

Parts:
C36, C37, C38, C40, C41, C43, C46, C47, C48, C49: 100nF; C_0402_1005Metric
C39, C42, C44, C45: 1µF; C_0402_1005Metric
J10: 后摄 OV2640; FPC_0.5mm_24P_Placeholder
J11: 前摄 30 万（型号待定）; FPC_0.5mm_24P_Placeholder
R63, R64: 33R; R_0402_1005Metric
R65, R66, R67, R70: 10k; R_0402_1005Metric
R68: 4.7k; R_0402_1005Metric
R69: 10k (不贴); R_0402_1005Metric; not fitted
R71: 0R; R_0402_1005Metric
R72, R73: 0R (不贴); R_0402_1005Metric; not fitted
U12, U13, U14: 74CBTLV3257; TSSOP-16_4.4x5mm_P0.65mm
U15: 2.8 V LDO; SOT-23-5
U16: 1.2 V LDO; SOT-23-5
Y1: 24 MHz 有源晶振; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1V2: C42.1, C43.1, J10.10 (DVDD), R73.1, U16.5 (V_{OUT})
+2V8: C39.1, C40.1, C41.1, J10.4 (AVDD), J11.4 (AVDD), R72.1, U15.5 (V_{OUT})
+3V3: C36.1, C37.1, C38.1, C44.1, C45.1, C46.1, C47.1, J10.11 (DOVDD), R65.1, R66.1, R67.1, R69.1, R71.1, U12.16 (VCC), U13.16 (VCC), U14.16 (VCC), U15.1 (V_{IN}), U16.1 (V_{IN}), Y1.4 (Vdd); also elsewhere on the board
CAMF_D0: J11.19 (Y2), U12.3 (1B2)
CAMF_D1: J11.21 (Y3), U12.6 (2B2)
CAMF_D2: J11.22 (Y4), U12.10 (3B2)
CAMF_D3: J11.20 (Y5), U12.13 (4B2)
CAMF_D4: J11.18 (Y6), U13.3 (1B2)
CAMF_D5: J11.16 (Y7), U13.6 (2B2)
CAMF_D6: J11.14 (Y8), U13.10 (3B2)
CAMF_D7: J11.12 (Y9), U13.13 (4B2)
CAMF_DVDD: C48.1, J11.10 (DVDD), R73.2
CAMF_HREF: J11.9 (HREF), U14.10 (3B2)
CAMF_IOVDD: C49.1, J11.11 (DOVDD), R71.2, R72.2
CAMF_PCLK: J11.17 (PCLK), U14.3 (1B2)
CAMF_PWDN: J11.8 (PWDN), R66.2; also elsewhere on the board
CAMF_VSYNC: J11.7 (VSYNC), U14.6 (2B2)
CAMF_XCLK: J11.13 (XCLK), R64.2
CAMR_D0: J10.19 (Y2), U12.2 (1B1)
CAMR_D1: J10.21 (Y3), U12.5 (2B1)
CAMR_D2: J10.22 (Y4), U12.11 (3B1)
CAMR_D3: J10.20 (Y5), U12.14 (4B1)
CAMR_D4: J10.18 (Y6), U13.2 (1B1)
CAMR_D5: J10.16 (Y7), U13.5 (2B1)
CAMR_D6: J10.14 (Y8), U13.11 (3B1)
CAMR_D7: J10.12 (Y9), U13.14 (4B1)
CAMR_HREF: J10.9 (HREF), U14.11 (3B1)
CAMR_PCLK: J10.17 (PCLK), U14.2 (1B1)
CAMR_PWDN: J10.8 (PWDN), R65.2; also elsewhere on the board
CAMR_VSYNC: J10.7 (VSYNC), U14.5 (2B1)
CAMR_XCLK: J10.13 (XCLK), R63.2
CAM_D0: U12.4 (1A); also elsewhere on the board
CAM_D1: U12.7 (2A); also elsewhere on the board
CAM_D2: U12.9 (3A); also elsewhere on the board
CAM_D3: U12.12 (4A); also elsewhere on the board
CAM_D4: U13.4 (1A); also elsewhere on the board
CAM_D5: U13.7 (2A); also elsewhere on the board
CAM_D6: U13.9 (3A); also elsewhere on the board
CAM_D7: U13.12 (4A); also elsewhere on the board
CAM_HREF: U14.9 (3A); also elsewhere on the board
CAM_PCLK: U14.4 (1A); also elsewhere on the board
CAM_PWR_EN: R68.1, R69.2, U15.3 (CE), U16.3 (CE), Y1.1 (EN); also elsewhere on the board
CAM_RST: J10.6 (RESET), J11.6 (RESET), R67.2; also elsewhere on the board
CAM_SEL: R70.1, U12.1 (S), U13.1 (S), U14.1 (S); also elsewhere on the board
CAM_VSYNC: U14.7 (2A); also elsewhere on the board
CAM_XCLK: R63.1, R64.1, Y1.3 (OUT)
GND: C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, J10.2 (AGND), J10.15 (DGND), J10.MP (SHELL), J11.2 (AGND), J11.15 (DGND), J11.MP (SHELL), R68.2, R70.2, U12.8 (GND), U12.15 (~OE), U13.8 (GND), U13.15 (~OE), U14.8 (GND), U14.15 (~OE), U15.2 (V_{SS}), U16.2 (V_{SS}), Y1.2 (GND); also elsewhere on the board
I2C_SCL: J10.5 (SIO_C), J11.5 (SIO_C); also elsewhere on the board
I2C_SDA: J10.3 (SIO_D), J11.3 (SIO_D); also elsewhere on the board

Notes on the sheet:
摄像头排线座（24P 0.5mm）
并口总线切换（CAM_SEL = 0 后摄，1 前摄）
两颗摄像头不直接并在一起：前摄型号没定， 不确定它待机时数据脚是不是高阻，所以第一版先用总线开关隔开。 以后确认两颗都能高阻，这三颗芯片可以去掉。
摄像头电源、时钟、控制
CAM_PWR_EN 同时开 2.8 V、1.2 V 和晶振，默认关。PWDN 默认上拉，两颗摄像头上电后都在待机。 摄像头的 IO 电源（排线 11 脚）必须一直有电，否则断电的摄像头会把共用的 I²C 总线拉死。 前摄如果是 GC0308 这类只用 11 脚单独供 2.8 V 的型号：11 脚改接 2.8 V， 并把 CAM_PWR_EN 的下拉换成上拉（让 2.8 V 上电即有）；10 脚的 0R 不贴。

Parts:
C50, C54, C56: 10µF; C_0603_1608Metric
C51, C55, C57: 100nF; C_0402_1005Metric
C52, C53: 220pF (不贴); C_0402_1005Metric; not fitted
FB1, FB2: 磁珠; L_0402_1005Metric
J12: 喇叭焊盘; SpeakerPads
J13: TF 卡座（带检测）; microSD_HC_Molex_104031-0811
MK1: MSM261S4030H0R
R74: 100k; R_0402_1005Metric
R75: 0R (不贴); R_0402_1005Metric; not fitted
R76: 2.2k; R_0402_1005Metric
R77: 22R; R_0402_1005Metric
R78, R79, R80, R81, R82: 10k; R_0402_1005Metric
U17: MAX98357A; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm

Connections:
+3V3: C50.1, C51.1, C56.1, C57.1, J13.4 (VDD), MK1.4 (CHIPEN), MK1.8 (VDD), R78.1, R79.1, R80.1, R81.1, R82.1; also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, J13.6 (VSS), J13.10 (DET_A), J13.11 (SHIELD), MK1.1 (GND), MK1.5 (L/R), R74.2, R75.2, R76.2, U17.3 (GND), U17.11 (GND), U17.15 (GND), U17.17 (PAD); also elsewhere on the board
I2S_BCLK: MK1.6 (SCK), U17.16 (BCLK); also elsewhere on the board
I2S_DIN: MK1.7 (SD), R74.1; also elsewhere on the board
I2S_DOUT: U17.1 (DIN); also elsewhere on the board
I2S_WS: MK1.3 (WS), U17.14 (LRCLK); also elsewhere on the board
PA_EN: R76.1, U17.4 (~SD_MODE); also elsewhere on the board
PA_GAIN: R75.1, U17.2 (GAIN_SLOT)
PA_OUTN: FB2.1, U17.10 (OUTN)
PA_OUTP: FB1.1, U17.9 (OUTP)
SD_CLK: R77.1; also elsewhere on the board
SD_CLK_R: J13.5 (CLK), R77.2
SD_CMD: J13.3 (CMD), R78.2; also elsewhere on the board
SD_D0: J13.7 (DAT0), R79.2; also elsewhere on the board
SD_D1: J13.8 (DAT1), R80.2
SD_D2: J13.1 (DAT2), R81.2
SD_D3: J13.2 (DAT3/CD), R82.2
SD_DET: J13.9 (DET_B); also elsewhere on the board
SPK_N: C53.1, FB2.2, J12.2
SPK_P: C52.1, FB1.2, J12.1
VSYS: C54.1, C55.1, U17.7 (VDD), U17.8 (VDD); also elsewhere on the board

Notes on the sheet:
I²S 麦克风
L/R 接地 = 左声道；CHIPEN 接高 = 一直工作。 数据线下拉 100k 是数据手册的要求。 这颗是顶部进音，外壳的进音孔要对着它；要底部进音得换型号。
I²S 功放（MAX98357A）和喇叭
功放直接用电池电压供电，输出功率比用 3.3 V 大。 PA_EN 高：工作（取左声道）；低：关断。2.2k 下拉保证上电时是关断。 不用更便宜的 NS4168：它的逻辑高电平要到 0.7 × 供电电压，用电池供电时 3.3 V 信号不够。 增益脚悬空 = 9 dB；贴 0R 接地 = 12 dB。
TF 卡（SD 一线模式：CLK、CMD、D0）
D1、D2、D3 不接主控，只上拉。D3 必须为高，卡才会进 SD 模式。 卡检测开关接扩展芯片，插卡时拉低（极性随卡座型号，待核对）。

Board: 6 copper layers, 64.0 x 34.0 mm, 210 parts (34 on the bottom side), 167 nets.

## Code that names these connections

File hardware/esp32-s3-board/kicad/gen/design.py (part):

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              "D+": "USBC_DP", "D-": "USBC_DM"}, nc=["SBU1", "SBU2"],
             value="Type-C 16P", fp="Connector_USB:USB_C_Receptacle_HRO_TYPE-C-31-M-12")
    sh.place("Power_Protection:USBLC6-2SC6", 106.68, 50.8,
             {"I/O1": "USBC_DP", "I/O2": "USBC_DM", "GND": "GND", "VBUS": "VBUS"})   # pin 5 to VBUS, as in ST's circuit
    sh.hlist(106.68, 81.28, [("R", "USBC_CC1", "GND", "5.1k"), ("R", "USBC_CC2", "GND", "5.1k")])
    sh.D(88.9, 114.3, "GND", "VBUS", "TVS 5V", "Device:D_TVS", "up", fp="Diode_SMD:D_SOD-123F")
    sh.text(15.24, 121.92, "USB 数据线只去 ESD 管和主控的全速 USB 口（GPIO33 / 34），不接充电芯片，\n"
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# Module pad number -> net (ESP32-S31-WROOM-1U datasheet v0.5, table 3-1; Espressif's official KiCad symbol).
ESP_PINS = {
    "[1,40,41,62,64]": "GND", "2": "+3V3", "3": "ESP_EN",
    "8": "EXP_INT",      # GPIO0  (LP IO: wakes from deep sleep)
    "9": "TP_INT",       # GPIO1  (LP IO)
    "4": "I2C_SDA",      # GPIO2
    "5": "I2C_SCL",      # GPIO3
    "6": "I2S_BCLK",     # GPIO4
    "7": "I2S_WS",       # GPIO5
    "10": "I2S_DOUT",    # GPIO6  amplifier data
    "11": "I2S_DIN",     # GPIO7  microphone data
    **{str(42 + i): f"LCD_D{i}" for i in range(12)},          # GPIO8 .. 19 = LCD_DATA0 .. 11 (IO MUX)
    "15": "SD_D0", "16": "SD_D1", "17": "SD_D2", "18": "SD_D3",  # GPIO20 .. 23 (SDMMC slot 0, fixed)
    "19": "SD_CLK", "20": "SD_CMD",                             # GPIO24 / 25
    "13": "ESP_DM", "14": "ESP_DP",                             # GPIO33 / 34: USB Serial/JTAG (full speed) to Type-C
    "12": "LCD_D12",     # GPIO35 (GPIO matrix)
    "21": "LCD_D13",     # GPIO36 strapping (VDD_SPI), pulled up inside the module
    "22": "LCD_D14",     # GPIO37 strapping
    "23": "LCD_D15",     # GPIO38
    "24": "LCD_BL_PWM",  # GPIO39
    "25": "LCD_PCLK",    # GPIO40
    "28": "ESP_SPARE",   # GPIO42
    "29": "LCD_DE", "30": "LCD_HSYNC", "31": "LCD_VSYNC",      # GPIO43 / 44 / 45
    "32": "CAM_D0", "33": "CAM_D1",                             # GPIO46 / 47 = CAM_DATA0 / 1
    **{str(56 + i): f"CAM_D{2 + i}" for i in range(6)},        # GPIO48 .. 53 = CAM_DATA2 .. 7
    "34": "CAM_PCLK",      # GPIO54
    "35": "ESP_CAM_XCLK",  # GPIO55
    "38": "CAM_VSYNC",     # GPIO56
    "39": "CAM_HREF",      # GPIO57
    "37": "U0TXD",         # GPIO58 = UART0 TXD
    "36": "U0RXD",         # GPIO59 = UART0 RXD
    "26": "CHG_INT",       # GPIO60 strapping: high at boot (charger INT is open drain with a pull-up)
    "27": "ESP_BOOT",      # GPIO61 strapping: low at reset = download mode
    "54": "LTE_USB_DM", "55": "LTE_USB_DP",                     # dedicated high-speed USB OTG -> Air780E
}
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        value="Air780E（北美版换贴 Air780EEN）")
    sh.hlist(238.76, 142.24, [
        ("R", "LTE_IOSEL", "GND", "0R", "dnp"),
        ("R", "VDD_4G", "LTE_VBUS", "10k"),      # fitted: the module's USB-detect pin is high whenever the module has power
    ])
    tps = ["LTE_PWRKEY", "LTE_VDD_EXT", "LTE_USB_BOOT", "LTE_USB_DP", "LTE_USB_DM", "LTE_VBUS",
           "LTE_RXD", "LTE_TXD", "LTE_DBG_RX", "LTE_DBG_TX"]
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
File hardware/esp32-s3-board/kicad/gen/power.py (part):

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
# ============================== back ==============================================================
# ---- system supply (VSYS): chip pins 15 / 16 -> neck -> 2 mm strip along y = 6.2 .. 8.2 -> Air780E load switch.
# The strip passes through the supply pads of C5, C6 and L1; the star point of PWR-16 is where the neck meets it:
# the Air780E branch runs right, the vias to the front (amplifier, 3.3 V, backlight) sit at the left end.
t("VSYS", B, 2.0, (6.15, 7.2), (17.36, 7.2))
t("VSYS", B, 0.78, (7.9, 10.2), (7.9, 9.6))                 # on the two pins
t("VSYS", B, 1.1, (7.8, 8.9), (7.8, 8.5))                   # neck, widening away from the pins
for x in (5.45, 6.35):
    for y in (6.7, 7.6):
        v("VSYS", x, y)                                     # PWR-8: four vias to the front trunk
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# The trunk steps 0.7 mm to the left where it passes the charger's four signal pins (back, y = 13.3 .. 14.4):
# with the 5 V strip on the back to their right, the pins had 0.4 mm of room for vias below them.
t("VSYS", F, 2.0, (5.9, 7.2), (5.6, 8.2), (5.6, 12.0), (4.9, 12.7), (4.9, 15.9), (5.6, 16.6), (5.6, 23.4))
t("VSYS", F, 0.75, (4.2, 21.7), (4.9, 21.7))               # amplifier pins 7 / 8
t("VSYS", F, 0.5, (6.0, 21.7), (6.7, 21.7))                # its 100 nF
t("VSYS", F, 1.0, (6.5, 8.05), (7.6, 8.05))                # input capacitor of the 3.3 V buck
t("VSYS", F, 0.6, (7.6, 8.05), (9.55, 8.05))               # ... and its VIN pin
t("VSYS", F, 0.3, (8.5, 8.05), (8.5, 7.3), (9.0, 6.6), (9.415, 6.5))   # enable pull-up
t("VSYS", F, 0.2, (16.4, 7.06), (16.49, 7.825))            # gate pull-up of the load switch
# backlight feed (about 0.2 A): 0.4 mm from the end of the trunk
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
# ---- 3.3 V buck (PWR-11 / PWR-12)
t("GND", F, 0.6, (11.8, 9.0), (8.55, 9.0), (8.1, 9.5), (7.575, 9.955))   # pin 2 -> under the chip -> input capacitor
t("BUCK_SW", F, 0.6, (11.9, 8.05), (13.5, 7.9))                        # 0.65 mm from the pin to the inductor
t("+3V3", F, 1.4, (14.95, 8.2), (14.95, 9.6))                          # inductor -> C10, with two vias to the 3.3 V layer
v("+3V3", 14.55, 8.8)
v("+3V3", 15.35, 8.8)
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# Kept by hand next to the geometry above: where pieces overlap, the width is that of the copper they form together.
PATH = {
    "VBAT": [(2.0, 1.4), (1.5, 1.5), (2.0, 1.4), (0.78, 0.6)],     # band, corner, band, the two pins
    "VSYS": [(0.78, 0.4), (1.1, 1.25), (2.0, 9.8)],                # at the pins, neck, strip to the load switch
    "VDD_4G": [(1.4, 1.8), (2.6, 2.6), (1.7, 0.3)],                # at the drain, capacitor pad -> pins, the two pins
}

# ---- TF socket (back, bottom edge) under the microphone (front): the pins can only get out through the 1 mm
# between the microphone's two pad rows (y = 30.8 .. 31.8). Left to itself the +3V3 stub of pin 4 runs 3 mm to
# the right to find a via and shuts in pin 5 (SD_CLK_R). Both go straight up instead.
t("+3V3", B, 0.3, (51.1, 32.6), (51.1, 32.0), (50.95, 31.3))
v("+3V3", 50.95, 31.3, 0.45, 0.2)
t("SD_CLK_R", B, 0.15, (52.2, 32.6), (52.2, 32.2), (51.9, 31.35))
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v("USBC_DP", 31.25, 23.5, 0.45, 0.2)
t("USBC_DP", F, 0.19, (31.25, 23.5), (32.4, 22.35), (33.55, 22.35))
t("USBC_DP", F, 0.19, (31.25, 23.5), (31.1, 23.65), (31.1, 24.2))
t("USBC_DP", F, 0.19, (31.05, 25.2), (31.05, 26.4))                      # pin 6 to pin 1, under the chip
t("USBC_DM", B, 0.19, (31.75, 25.1), (31.75, 25.05), (32.0, 24.8), (32.5, 24.8), (32.75, 25.05), (32.75, 25.1))
t("USBC_DM", B, 0.19, (32.75, 25.05), (32.75, 24.7), (33.15, 24.3), (33.65, 24.3), (33.65, 23.6), (33.3, 23.25),
  (32.75, 23.25))
v("USBC_DM", 32.75, 23.25, 0.45, 0.2)
t("USBC_DM", F, 0.19, (32.75, 23.25), (33.2, 22.8), (33.55, 22.8))
t("USBC_DM", F, 0.19, (32.75, 23.25), (32.75, 23.7), (32.95, 23.9), (32.95, 24.1))
t("USBC_DM", B, 0.19, (32.8, 26.4), (32.8, 27.85), (33.0, 28.05))        # pin 3, from the contact's lower end
v("USBC_DM", 33.0, 28.05, 0.45, 0.2)
t("USBC_DM", F, 0.19, (33.0, 28.05), (33.0, 27.5))

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